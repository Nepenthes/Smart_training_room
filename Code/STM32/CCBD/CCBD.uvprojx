# Keil uVision project CCBD.uvprojx, settings and files
target 智慧实训室_集控中心板 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103RC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IROM(0x08000000,0x40000) IRAM(0x20000000,0xC000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: CCBD
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\User;.\User\reWrite;.\Member_Detect;.\Member_Transfer
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group 用户文件
    ./User/: UserMain.c Bsp.c delay.c
  group 通讯构件
    ./Member_Transfer/: UART_dataTransfer.c
  group 控制器构件
    ./Member_Control/: sourceControl.c
  group 系统驱动改写
    ./User/reWrite/: USART_STM32F10x.c
  group 备忘录
    ./User/: 备忘录.txt
software components: CMSIS:CORE 5.0.2, CMSIS:RTOS:Keil RTX 4.81.1, CMSIS Driver:CAN 1.6, Device:GPIO 1.3, Device:Startup 1.0.0, Device:StdPeriph Drivers:ADC 3.5.0, Device:StdPeriph Drivers:Framework 3.5.1, Device:StdPeriph Drivers:GPIO 3.5.0, Device:StdPeriph Drivers:RCC 3.5.0, Device:StdPeriph Drivers:RTC 3.5.0, Device:StdPeriph Drivers:SPI 3.5.0, Device:StdPeriph Drivers:TIM 3.5.0, Device:StdPeriph Drivers:USART 3.5.0
